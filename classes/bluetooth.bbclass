# Empty class to trick gstreamer 1.10.4
