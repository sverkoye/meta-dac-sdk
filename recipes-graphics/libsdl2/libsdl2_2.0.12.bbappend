FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
SRC_URI += "file://sdl2-wayland-input-fix.patch"